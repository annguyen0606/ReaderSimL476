# IAR project ReaderNFC.ewp, settings and files
configuration ReaderNFC (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L476xx; USE_TINZ
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; D:\HocLapTrinhViDieuKhien\HocLapTrinhSTM32\NUCLEO-L476RG\ReaderNFC\ReaderNFC\DucaLib\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ReaderNFC.hex
  ILINK.IlinkOutputFile: ReaderNFC.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group DucaLib/inc
    ../DucaLib/inc/: bcdencode.h i2c-lcd.h ndef.h nfcm1833_module.h nfcm1833tiny.h nfcm1833tinz.h
  group DucaLib/src
    ../DucaLib/src/: bcdencode.c i2c-lcd.c ndef.c nfcm1833_module.c nfcm1833tiny.c nfcm1833tinz.c
